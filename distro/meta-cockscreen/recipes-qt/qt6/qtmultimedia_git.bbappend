PACKAGECONFIG:append = " alsa gstreamer"
PACKAGECONFIG:remove = " ffmpeg pulseaudio spatialaudio spatialaudio_quick3d"
QT_DEFAULT_MEDIA_BACKEND = "gstreamer"
